<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\VL53L1X_RangingExample_F401.ewp</path>
  </project>
  <batchBuild />
</workspace>
